# Keil uVision project httpd.uvprojx, settings and files
target V2M-MPS2 (6130001::V6.13.1::.\ARMCLANG)
  device: IOTKit_CM33_FP ARM
  pack: Keil.V2M-MPS2_IOTKit_BSP.1.4.2
  cpu: IRAM(0x38000000,0x00200000) IRAM2(0x28200000,0x00200000) IROM(0x10000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: httpd
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x38000000 size 0x200000
  memory RVCT10: RAM 0x28200000 size 0x200000
  group Source
    ./: main.c httpd.c fs.c
  group Documentation
    ./: abstract.txt
software components: CMSIS:CORE 5.4.0, CMSIS:RTOS2:Keil RTX5 5.5.1, Board Support:Buttons 2.0.0, Board Support:Common 2.0.0, Board Support:Graphic LCD 2.0.0, Board Support:LED 2.0.0, CMSIS Driver:Ethernet:LAN9220 1.0.0, Device:Startup 1.0.3, Network:API 2.1.2, Network:CORE 2.1.2, Network:Driver:Ethernet 2.1.2, Network:Interface:Ethernet 2.1.2, Network:RTOS 2.1.2
