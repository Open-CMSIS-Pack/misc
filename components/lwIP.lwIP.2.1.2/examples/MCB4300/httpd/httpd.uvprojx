# Keil uVision project httpd.uvprojx, settings and files
target LPC4357 Flash (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC4357:Cortex-M4 NXP
  pack: Keil.LPC4300_DFP.2.9.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x20000000,0x10000) IROM(0x1A000000,0x80000) IROM2(0x1B000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: httpd
  AfterMake: $K/ARM/BIN/ElfDwT.exe !L BASEADDRESS(0x1A000000)
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x1a000000 size 0x80000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group Source
    ./: main.c httpd.c fs.c
  group Documentation
    ./: abstract.txt
software components: CMSIS:CORE 5.4.0, CMSIS:RTOS2:Keil RTX5 5.5.1, Board Support:Graphic LCD 1.0.0, Board Support:LED 1.0.0, CMSIS Driver:Ethernet MAC 2.12, CMSIS Driver:Ethernet PHY:DP83848C 6.2.0, CMSIS Driver:SPI:SSP 2.11, Device:GPDMA 1.6, Device:GPIO 1.1, Device:SCU 1.1, Device:Startup 1.0.0, Network:API 2.1.2, Network:CORE 2.1.2, Network:Driver:Ethernet 2.1.2, Network:Interface:Ethernet 2.1.2, Network:RTOS 2.1.2
